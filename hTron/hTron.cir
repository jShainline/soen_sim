* Generated by Xic from cell noname
.tran 1p 20ns
.plot tran L1#branch L0#branch
I0 0 1 pwl(0 0 0.1ns 0 0.2ns 35u)
I1 0 4 pwl(0 0 5ns 0 10ns 10u)
L0 1 2 100n
L1 3 0 100p
N0 1 4 3 ntron1
R0 2 0 2
.model ntron1 ntron()

* Nb 30 A/cm2
.save @I1[c]
.save @I0[c]
