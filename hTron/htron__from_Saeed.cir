* Generated by Xic from cell noname

N0 1 3 2 4 htron1
I0 0 5 pwl(0 0 5n 0 15n 5u 20n 5u 25n 0 30n 0)
I1 0 6 pwl(0 0 0.1n 0 0.2n 20u)
L0 5 1 1f
L1 6 2 1f
L2 3 0 1f
L3 4 0 1f
R0 2 0 100e3

.model htron1 htron(I_gate_c = 3e-6,I_channel_c=16e-6, r_gate_c=100e3,r_channel_c=5e3)

.control
tran 10p 30n uic
plot L0#branch v(1) v(2)
.endc
